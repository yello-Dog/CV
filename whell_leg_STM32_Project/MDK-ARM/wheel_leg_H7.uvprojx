# Keil uVision project wheel_leg_H7.uvprojx, settings and files
target wheel_leg_H7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: wheel_leg_H7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../User/Devices/BMI088/Inc;../User/Devices/PS2/Inc;../User/Bsp/DWT/Inc;../User/Algorithem/mahony/Inc;../User/App/INS_task/Inc;../User/App/chassisL_task/Inc;../User/Devices/DM_Motor/Inc;../User/App/chassisR_task/Inc;../User/Algorithem/PID/Inc;../User/Algorithem/KalmanFilter/Inc;../User/App/Observer_task/Inc;../User/Bsp/CAN/Inc;../User/Algorithem/VMC/Inc;../User/Algorithem/matlab_vmc;../User/Debug;../User/App/IMU_TempCtrlTask/Inc;../User/Devices/Buzzer/Inc
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c fdcan.c spi.c tim.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Devices
    ../User/Devices/BMI088/Src/: BMI088driver.c BMI088Middleware.c
    ../User/Devices/PS2/Src/: ps2_drv.c
    ../User/Devices/DM_Motor/Src/: dm4310_drv.c
    ../User/Devices/Buzzer/Src/: buzzer.c
  group Algorithem
    ../User/Algorithem/PID/Src/: fai0_diff_pd.c pid.c yaw_gain_calc.c
    ../User/Algorithem/mahony/Src/: mahony_filter.c
    ../User/Algorithem/KalmanFilter/Src/: kalman_filter.c
    ../User/Algorithem/VMC/Src/: VMC.c
    ../User/Algorithem/matlab_vmc/: fivebar_kinematics_func.c fivebar_velocity_func.c fivebar_vmc_torque_func.c
  group Bsp
    ../User/Bsp/DWT/Src/: bsp_dwt.c
    ../User/Bsp/CAN/Src/: can_bsp.c
  group App
    ../User/App/INS_task/Src/: INS_task.c
    ../User/App/Observer_task/Src/: observe_task.c
    ../User/App/chassisL_task/Src/: chassisL_task.c
    ../User/App/chassisR_task/Src/: chassisR_task.c
    ../User/App/IMU_TempCtrlTask/Src/: imu_temp_ctrl.c
  group Debug
    ../User/Debug/: DebugConfig.h
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2
